
IMAGE_INSTALL += "\
    cups \
	cups-doc \
	cups-filters \
	bootmmc-dbg \
	brlaser \
	ghostscript \
	dhcp-client \
	wireless-tools \
	bind \
	wpa-supplicant \
	wlan-firmware \
	avahi-daemon \
"
